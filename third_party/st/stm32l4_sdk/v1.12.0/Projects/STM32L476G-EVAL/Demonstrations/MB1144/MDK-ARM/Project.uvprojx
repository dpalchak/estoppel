# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL-MB1144 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476G_EVAL-MB1144 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_IOEXPANDER,USE_STM32L476G_EVAL_REVB
  c misc: --C99
  c include: ..\Core\inc;..\Config;..\..\..\..\..\Utilities\CPU;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32L476G_EVAL;..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\Drivers\CMSIS\Include
  asm include: ..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\Project.sct
  link misc: --diag_suppress=L6329
  group Application/User/Modules/AudioRecorder
    ../Modules/audiorecorder/: audiorecorder_win.c audiorecorder_app.c
  group Application/User/Modules/Game
    ../Modules/game/: game_win.c
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
  group Middlewares/STemWin/Config
    ../Config/: LCDConf.c GUIConf.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_OS_Keil.lib
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_flash.c stm32l4xx_hal_uart.c stm32l4xx_hal_sd.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rcc.c stm32l4xx_hal_sai.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_crc.c stm32l4xx_ll_usb.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_spi.c stm32l4xx_hal_cryp.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_sram.c stm32l4xx_hal_i2c.c stm32l4xx_hal_tim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_nor.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_rtc.c stm32l4xx_hal_flash_ex.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc_scsi.c usbd_msc_data.c usbd_msc.c
  group Application/User/Modules/ImageBrowser
    ../Modules/imagebrowser/: imagebrowser_win.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Application/User/Modules/FileBrowser
    ../Modules/filebrowser/: filebrowser_win.c filebrowser_app.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c croutine.c timers.c queue.c
  group Application/User/Modules/IDDMeasure
    ../Modules/iddmeasure/: iddmeasure_win.c iddmeasure_app.c
  group Middlewares/USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group Application/User/Modules/USBDevice
    ../Modules/usbdevice/: usbd_storage.c usbd_desc.c usbd_app.c usbd_win.c
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval_ts.c stm32l476g_eval_sram.c stm32l476g_eval_sd.c stm32l476g_eval_nor.c stm32l476g_eval.c stm32l476g_eval_io.c stm32l476g_eval_idd.c stm32l476g_eval_audio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User/Modules/System
    ../Modules/system/: system_win.c
  group Application/User/Modules/AudioPlayer
    ../Modules/audioplayer/: audioplayer_app.c audioplayer_win.c
  group Application/User/Core
    ../Core/Src/: k_temperature.c k_modules_res.c k_module.c k_calibration.c main.c k_log.c k_sd_diskio.c k_menu.c k_mem.c k_startup.c stm32l4xx_it.c k_bsp.c k_rtc.c k_storage.c stm32l4xx_hal_timebase_tim.c
