# IAR project Project.ewp, settings and files
configuration STM32L476G-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; USE_STM32L476G_DISCO_REVB; BSP_AUDIO_USE_RTOS; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Config; ..\Modules\audioplayer; ..\Modules\audiorecorder; ..\Modules\batterymeasure; ..\Modules\compass; ..\Modules\iddmeasure; ..\Modules\main_app; ..\Modules\soundmeter; ..\Modules\guitartuner; ..\..\..\..\Utilities\CPU; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32L476G-Discovery; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32CubeDemo_STM32L476G-Discovery-MB1184-C01.hex
  ILINK.IlinkOutputFile: STM32CubeDemo_STM32L476G-Discovery-MB1184-C01.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\Modules\soundmeter\lib_smr_CM4F_IAR.a; ..\Modules\guitartuner\lib_GuitarTuner_CM4F_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: k_demo.c k_menu.c k_module.c main.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
  group Application/User/Modules/AudioPlayer
    ../Modules/audioplayer/: audioplayer.c
  group Application/User/Modules/AudioRecorder
    ../Modules/audiorecorder/: audiorecorder.c
  group Application/User/Modules/BatteryMeasure
    ../Modules/batterymeasure/: batterymeasure.c
  group Application/User/Modules/Compass
    ../Modules/compass/: compass.c
  group Application/User/Modules/GuitarTuner
    ../Modules/guitartuner/: guitartuner.c
  group Application/User/Modules/IddMeasure
    ../Modules/iddmeasure/: iddmeasure.c
  group Application/User/Modules/MainApp
    ../Modules/main_app/: main_app.c
  group Application/User/Modules/SoundMeter
    ../Modules/soundmeter/: soundmeter.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../Drivers/BSP/Components/lsm303c/: lsm303c.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L476G-Discovery
    ../../../../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c stm32l476g_discovery_audio.c stm32l476g_discovery_compass.c stm32l476g_discovery_glass_lcd.c stm32l476g_discovery_gyroscope.c stm32l476g_discovery_idd.c stm32l476g_discovery_qspi.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
